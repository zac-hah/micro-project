# Keil uVision project stm32_vga.uvproj, settings and files
target stm32_64k (ARM-ADS)
  device: STM32F103T8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: stm32_vga
  c flags: Optim=4 oTime=1 OneElfS=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_MD USE_STDPERIPH_DRIVER
  c include: .\CMSIS\CM3\CoreSupport;.\CMSIS\CM3\DeviceSupport\ST\STM32F10x;.\STM32F10x_StdPeriph_Driver\inc;..\artekit_space_invaders
  memory RVCT4: ROM 0x8000000 size 0x9000
  memory RVCT5: ROM 0x8009000 size 0x1000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group source
    ./: main.c stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h video.c video.h gdi.c font5x7.c mth.c sys.c startup_stm32f10x_md.s demo.c space_invaders.c spLogo.c
  group st
    ./CMSIS/CM3/CoreSupport/: core_cm3.h core_cm3.c
    ./CMSIS/CM3/DeviceSupport/ST/STM32F10x/: stm32f10x.h system_stm32f10x.c system_stm32f10x.h
    ./STM32F10x_StdPeriph_Driver/src/: stm32f10x_tim.c misc.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_gpio.c stm32f10x_spi.c stm32f10x_rcc.c
